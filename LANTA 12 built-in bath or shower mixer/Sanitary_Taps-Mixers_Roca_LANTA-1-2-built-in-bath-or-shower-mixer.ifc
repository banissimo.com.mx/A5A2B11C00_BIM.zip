Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Taps-Mixers_Roca_LANTA-1-2-built-in-bath-or-shower-mixer.ifc
Time: 2019-10-18T07:16:41
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: LANTA 1/2" built-in bath or shower mixer. To completed with RocaBox 525869403
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): LANTA 1/2" built-in bath or shower mixer. To completed with RocaBox 525869403; SKU (BO_prodsku): 5A2B11C00; ManufacturName (BO_Manufac): Roca; BrandUrl (BO_brandurl): http://www.roca.com; ProductFamily (BO_prodfam): Lanta; ProductGroup (BO_prodgroup): FAUCETS; ManufacturCountry (BO_mancont): Spain; DesignCountry (BO_designcont): Spain; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/roca/product/5A2B11C00; ProductDataUrl (BO_prodaturl): bimobject.com/roca/product/5A2B11C00; ProductUrl (BO_producturl): http://www.roca.com/catalogue/collections/faucets-collections/lanta/12built-bath-shower-mixer-completed-rocabox-a525869403-5A2B11C00#!A5A2B11C00; InstallationInstructions (BO_montins): http://www.roca.com/RocaResourceServlet/resources/getMainResource?idObject=%7BB7C30427-F406-4B17-BBE1-EEBC2667F677%7D; TechnicalDescription (BO_techcert): http://www.roca.com/servlet/getTechnicalDrawingTransformation?productId=4453&idObject=%7B18BD7B87-23A7-4C3F-BD7C-F0387EF3112C%7D; InstructionVideo (BO_youtube): https://www.youtube.com/watch?v=68jtjk-3_i4; MaterialMain (BO_mainmat): Brass; MaterialSecondary (BO_secmat): Chrome; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Taps & Mixers; BimObjectCategoryCode (BO_bocat_code): sanitary-taps-mixers; IfcClassification (BO_ifcclas): Sanitary Terminal; UnspcCode (BO_unspc): 3018; Uniclass14Code (BO_uniclass_1_4_code): L725111; Uniclass14Description (BO_uniclass_1_4_desc): Mixer taps; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_87; Uniclass2015Description (BO_uniclass2015_desc): Taps and water supply outlet fittings; OmniClassCode (BO_omniclass_code): 23-31 11 00; OmniClassDescription (BO_omniclass_name): Faucets; MasterFormat2014Code (BO_masterformat2014_code): 22 41 39; MasterFormat2014Description (BO_masterformat2014_name): Residential Faucets, Supplies, and Trim; UniFormat2Code (BO_uniformat2_code): D2010; UniFormat2Description (BO_uniformat2_name): Plumbing Fixtures; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
